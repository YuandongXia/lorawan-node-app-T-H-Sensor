# IAR project cdc-bl.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L052R8 ST STM32L052R8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L052xx; USE_USB_CDC; UART_TXPA9_RXPA10; USE_NO_TIMER; USE_DEBUGGER; USE_HSE; HSE_VALUE=12000000
  ICCARM.CCDiagSuppress: Pa050, Pa093
  ICCARM.CCIncludePath2: ..\..\..\src\app\common; ..\..\..\src\hal\mcu\cmsis; ..\..\..\src\hal\mcu\ST\STM32_USB-FS-Device_Driver\inc; ..\..\..\src\hal\mcu\ST\stm32l0; ..\..\..\src\hal\rhf1s001; ..\..\..\src\hal\rhf1s001\usb\cdc\inc; ..\..\..\src\lib; ..\..\..\src\lib\lorawan-node\src; ..\..\..\src\lib\lorawan-node\src\mac; ..\..\..\src\lib\lorawan-node\src\misc; ..\..\..\src\lib\lorawan-node\src\radio; ..\..\..\src\lib\lorawan-node\src\system; ..\..\..\src\lib\lorawan-node\src\system\crypto; ..\..\..\src\hal\mcu\user\stm32l0\usb\cdc\inc; ..\..\..\src\hal\mcu\user\stm32l0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cdc-bl.hex
  ILINK.IlinkOutputFile: cdc-bl.out
  ILINK.IlinkIcfFile: stm32l052xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../../../src/app/rhf1s001/cdc-bl/: main.c
    ../../../src/app/common/: ymodem.c
  group drv
    ../../../src/hal/mcu/user/stm32l0/: clock.c sys-irq.c
  group hal
    ../../../src/hal/mcu/user/stm32l0/: gpio-board.c hal-led.c hal-tim.c nvm-board.c usb-cdc-board.c
  group hal/bsp
    ../../../src/hal/mcu/ST/stm32l0/iar/: startup_stm32l052xx.s
    ../../../src/hal/mcu/ST/stm32l0/: system_stm32l0xx.c
  group hal/usb-cdc
    ../../../src/hal/mcu/user/stm32l0/usb/cdc/src/: usb_desc.c usb_istr.c usb_prop.c usb_pwr.c
  group lib
    ../../../src/hal/mcu/user/stm32l0/: flash.c
    ../../../src/lib/: nvm.c usb-cdc.c
  group lib/lorawan-node
    ../../../src/lib/lorawan-node/src/system/crypto/: aes.c cmac.c
    ../../../src/lib/lorawan-node/src/system/: gpio.c
  group lib/usb
    ../../../src/hal/mcu/ST/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
