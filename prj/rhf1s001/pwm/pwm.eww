<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\pwm.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>NDebug</name>
      <member>
        <project>pwm</project>
        <configuration>NDebug</configuration>
      </member>
      <member>
        <project>pwm</project>
        <configuration>NDebug-SINGTEL</configuration>
      </member>
      <member>
        <project>pwm</project>
        <configuration>NDebug-IWOW</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


