# IAR project lwaui.ewp, settings and files
configuration Debug-BL (ARM, debug)
  General.OGChipSelectEditMenu: STM32L052R8 ST STM32L052R8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L052xx; DISABLE_CMD_GPIO; USE_USB; USE_DEBUGGER; USE_BOOTLOADER; BOOTLOADER_12K; USE_HSE; HSE_VALUE=12000000; LORAMAC_EU868_20DBM; LORAMAC_FULL_MIB_PARAMETER; DISABLE_RF_DEBUG
  ICCARM.CCDiagSuppress: Pa050, Pa093
  ICCARM.CCIncludePath2: ..\..\..\src\app\common; ..\..\..\src\hal\mcu\cmsis; ..\..\..\src\hal\mcu\ST\stm32l0; ..\..\..\src\hal\rhf1s001; ..\..\..\src\lib\lorawan-node\src; ..\..\..\src\lib\lorawan-node\src\mac; ..\..\..\src\lib\lorawan-node\src\misc; ..\..\..\src\lib\lorawan-node\src\radio; ..\..\..\src\lib\lorawan-node\src\system; ..\..\..\src\lib\lorawan-node\src\system\crypto; ..\..\..\src\hal\mcu\user\stm32l0; ..\..\..\src\hal\mcu\user\stm32l0\usb\cdc; ..\..\..\src\lib\sensor; ..\..\..\src\lib; ..\..\..\src\hal\mcu\ST\STM32_USB-FS-Device_Driver\inc; ..\..\..\src\hal\mcu\user\stm32l0\usb\cdc\inc; ..\..\..\src\app\rhf1s001\lwaui
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: lwaui.srec
  ILINK.IlinkOutputFile: lwaui.out
  ILINK.IlinkIcfFile: stm32l052xx_flash_bl12k.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration NDebug-BL (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L052xx; DISABLE_CMD_GPIO; USE_USB; USE_BOOTLOADER; BOOTLOADER_12K; USE_HSE; HSE_VALUE=12000000; LORAMAC_EU868_20DBM; LORAMAC_FULL_MIB_PARAMETER
  ICCARM.CCIncludePath2: ..\..\..\src\app\common; ..\..\..\src\hal\mcu\cmsis; ..\..\..\src\hal\mcu\ST\stm32l0; ..\..\..\src\hal\rhf1s001; ..\..\..\src\lib\lorawan-node\src; ..\..\..\src\lib\lorawan-node\src\mac; ..\..\..\src\lib\lorawan-node\src\misc; ..\..\..\src\lib\lorawan-node\src\radio; ..\..\..\src\lib\lorawan-node\src\system; ..\..\..\src\lib\lorawan-node\src\system\crypto; ..\..\..\src\hal\mcu\user\stm32l0; ..\..\..\src\hal\mcu\user\stm32l0\usb\cdc; ..\..\..\src\lib\sensor; ..\..\..\src\lib; ..\..\..\src\hal\mcu\ST\STM32_USB-FS-Device_Driver\inc; ..\..\..\src\hal\mcu\user\stm32l0\usb\cdc\inc; ..\..\..\src\app\rhf1s001\lwaui; $TOOLKIT_DIR$\inc
  OBJCOPY.OOCOutputFile: RHF1S001_v2.4.1.bin
  group app
    ../../../src/app/common/: app-test.c cfg.c cmd.c gollum.c lw.c
    ../../../src/app/rhf1s001/lwaui/: I2C_HAL.c main.c SHT2x.c
  group drv
    ../../../src/hal/mcu/user/stm32l0/: adc-board.c gpio-board.c hal-eui.c hal-led.c i2c-board.c irq-board.c nvm-board.c rtc-board.c spi-board.c sys-irq.c usb-cdc-board.c
  group hal
    ../../../src/hal/rhf1s001/: board.c sx1276-board.c
    ../../../src/hal/mcu/user/stm32l0/: clock.c
  group hal/bsp
    ../../../src/hal/mcu/ST/stm32l0/iar/: startup_stm32l052xx.s
    ../../../src/hal/mcu/ST/stm32l0/: system_stm32l0xx.c
  group hal/usb
    ../../../src/hal/mcu/ST/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group hal/usb-cdc
    ../../../src/hal/mcu/user/stm32l0/usb/cdc/src/: usb_desc.c usb_istr.c usb_prop.c usb_pwr.c
  group lib
    ../../../src/lib/: checkbl.c led.c nvm.c usb-cdc.c
    ../../../src/lib/sensor/: sht21.c
    ../../../src/lib/lorawan-node/src/misc/: utilities.c
  group lib/lorawan-node
    ../../../src/lib/lorawan-node/src/system/crypto/: aes.c cmac.c
    ../../../src/lib/lorawan-node/src/system/: delay.c gpio.c timer.c
    ../../../src/lib/lorawan-node/src/mac/: LoRaMac.c LoRaMacCrypto.c
    ../../../src/lib/lorawan-node/src/radio/sx1276/: sx1276.c
