<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\lwaui.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>NDebug</name>
      <member>
        <project>lwaui</project>
        <configuration>NDebug</configuration>
      </member>
      <member>
        <project>lwaui</project>
        <configuration>NDebug-SINGTEL</configuration>
      </member>
      <member>
        <project>lwaui</project>
        <configuration>NDebug-IWOW</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


